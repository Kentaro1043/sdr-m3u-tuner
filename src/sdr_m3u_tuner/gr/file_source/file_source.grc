options:
  parameters:
    author: Kentaro1043
    description: 'Read audio wav file and sink that data. '
    generate_options: no_gui
    id: file_source
    output_language: python
    title: Audio source from file
  states: {}

blocks:
- name: pub_address_left
  id: variable
  parameters:
    value: random_url.make_tcp_url()
  states: {}
- name: pub_address_right
  id: variable
  parameters:
    value: random_url.make_tcp_url()
  states: {}
- name: source_file_path
  id: variable
  parameters:
    value: '"./audio.wav"'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '48000'
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '48000'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: source_file_path
    nchan: '2'
    repeat: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import random_url
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: pub_address_left
    timeout: '100'
    type: float
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: pub_address_right
    timeout: '100'
    type: float
  states: {}

connections:
- [blocks_throttle2_0, '0', zeromq_pub_sink_0, '0']
- [blocks_throttle2_0_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [blocks_wavfile_source_0, '1', blocks_throttle2_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
