options:
  parameters:
    author: Kentaro1043
    generate_options: qt_gui
    id: fmrx
    output_language: python
    title: FM reception
  states: {}

blocks:
- name: freq
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    maxFreqHz: 100e6
    minFreqHz: 70e6
    value: 80e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '10'
    deemph_tau: '75e-6'
    quad_rate: samp_rate*10
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /Users/kentaro/source/repos/github.com/Kentaro1043/sdr-m3u-tuner/test.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 250e3
    decim: '5'
    gain: '1'
    samp_rate: samp_rate*50
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    bw0: 1e6
    freq0: ' freq'
    gain0: '50'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate*50
    sync: none
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_pll_0, '0', blocks_wavfile_sink_0, '0']
- [analog_wfm_rcv_pll_0, '1', blocks_wavfile_sink_0, '1']
- [freq, valueout, freq, valuein]
- [low_pass_filter_0, '0', analog_wfm_rcv_pll_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
