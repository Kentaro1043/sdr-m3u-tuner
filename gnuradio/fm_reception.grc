options:
  parameters:
    author: Kentaro1043
    generate_options: no_gui
    id: fm_reception
    output_language: python
    title: FM reception
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '10'
    deemph_tau: '75e-6'
    quad_rate: samp_rate*10
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: ../tmp/sound.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ../tmp/test.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 250e3
    decim: '5'
    gain: '1'
    samp_rate: samp_rate*50
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    bw0: 1e6
    freq0: 80M
    gain0: '50'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate*50
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [blocks_throttle2_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_throttle2_1, '0', blocks_wavfile_sink_0, '1']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [blocks_wavfile_source_0, '1', blocks_throttle2_1, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_pll_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
